# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__
  c include: ..\libraries\HAL_Drivers;..\RT_Thread\components\libc\compilers\common\extension;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\RT_Thread\components\finsh;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\RT_Thread\libcpu\arm\cortex-m4;..\RT_Thread\components\drivers\include;..\libraries\HAL_Drivers\CMSIS\Include;..\RT_Thread\components\libc\compilers\common\extension\fcntl\octal;.;board\CubeMX_Config\Inc;..\RT_Thread\components\drivers\include;..\libraries\HAL_Drivers\config;..\RT_Thread\components\libc\posix\io\stdio;..\RT_Thread\libcpu\arm\common;..\RT_Thread\components\libc\compilers\common\include;..\RT_Thread\include;board;board\ports;applications;..\RT_Thread\components\drivers\include;..\RT_Thread\components\drivers\include;..\RT_Thread\components\libc\posix\io\poll;..\RT_Thread\components\libc\posix\ipc;.\applications\drive\lib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./applications/drive/source/: multi_button.c oled.c
    ./applications/: display.c
  group Compiler
    ../RT_Thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../RT_Thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../RT_Thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../RT_Thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../RT_Thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../RT_Thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../RT_Thread/components/drivers/misc/: pin.c
    ../RT_Thread/components/drivers/serial/: serial.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../RT_Thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../RT_Thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
